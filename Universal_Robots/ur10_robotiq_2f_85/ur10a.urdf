Commit message: a

File: Universal_Robots/ur10_robotiq_2f_85/ur10a.urdf (robot description, URDF)
Before this commit: robot ur10, 18 links, 17 joints
Joints:
- joint robotiq_85_base_joint: origin xyz=0 0 0.004 rpy=1.57079632679 0 3.141592653 -> xyz=0 0 0.004 rpy=0 0 0
