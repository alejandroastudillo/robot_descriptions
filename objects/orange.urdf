Commit message: modified orange.urdf

File: objects/orange.urdf (robot description, URDF)
Before this commit: robot orange, 1 links, 0 joints
Links:
- link body: geometry collision mesh filename=./meshes/orange.obj scale=1 1 1; visual mesh filename=./meshes/orange.obj scale=1 1 1
