Commit message: minor

File: objects/peach.urdf (robot description, URDF)
Before this commit: robot peach, 1 links, 0 joints
Links:
- link body: geometry collision mesh filename=./meshes/peach.obj scale=1 1 1; visual mesh filename=./meshes/peach.obj scale=1 1 1
